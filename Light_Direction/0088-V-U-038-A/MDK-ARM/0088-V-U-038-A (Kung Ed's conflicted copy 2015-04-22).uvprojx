# Keil uVision project 0088-V-U-038-A (Kung Ed's conflicted copy 2015-04-22).uvprojx, settings and files
target 0088-V-U-038-A (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 0088-V-U-038-A +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\0088-V-U-038-A;..\..\0088-V-U-038-A\DRV
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Libraries
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Startup
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ../: system_stm32f0xx.c
  group User
    ../: main.c stm32f0xx_it.c spi.c st.c i2c.c TxRx.c com.c
    ../DRV/: ak8975APIs.c bh1750fviAPIs.c lea6sAPIs.c mag3110APIs.c mcp2120APIs.c mpu6050APIs.c tmp75APIs.c us2400APIs.c autonetAPIs.c
